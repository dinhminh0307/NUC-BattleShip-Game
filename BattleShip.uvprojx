# Keil uVision project BattleShip.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: NUC140VE3CN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.16
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: BattleShip
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c include: C:\Keil_v5\Library\NUC100Series\Include;C:\Keil_v5\Library\CMSIS\Include;C:\Keil_v5\Library\StdDriver\Include;C:\Keil_v5\Library\NUC1xx-LB_002\Include;C:\Keil_v5\Library\NUMakerLib\Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: main.c
    C:/Keil_v5/Library/StdDriver/Source/: clk.c gpio.c uart.c spi.c
    C:/Keil_v5/Library/NUC1xx-LB_002/Source/: LCD.c Seven_Segment.c
    C:/Keil_v5/Library/NUC100Series/Source/: system_NUC100Series.c
    C:/Keil_v5/Library/NUC100Series/Source/ARM/: startup_NUC100Series.s
